# IAR project TWI_Master.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\lnk0t.xcl
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: __ATMEGA2560__
  XLINK.XclFile: E:\F Drive\Project\Bootloader project\Code\Common for All Devices\TWI_Master\TWI_Master.xcl
  group (top)
    ./: defines.h flash.h serial.c serial.h stdint.h TWI_Master.c
